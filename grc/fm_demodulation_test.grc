options:
  parameters:
    generate_options: qt_gui
    id: fm_demodulation_test
    output_language: python
    title: FM Demodulation
  states: {}

blocks:
- name: decimated_sample_rate
  id: variable
  parameters:
    value: '409600'
  states: {}
- name: rf_lpf_cutoff_frequency
  id: variable
  parameters:
    value: 75E3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2080000'
  states: {}
- name: tune_frequency
  id: variable_qtgui_entry
  parameters:
    label: Tune Frequency
    type: real
    value: 98.5E6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: decimated_sample_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '40960'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.05 * volume / 100
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/dominic/radio/data/test.wav
    samp_rate: '40960'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rf_lpf_cutoff_frequency
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5E3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '40960'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tune_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_wavfile_sink_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
